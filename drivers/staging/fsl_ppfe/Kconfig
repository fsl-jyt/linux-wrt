## drivers/staging/fsl_ppfe/Kconfig
```kconfig
config FSL_PPFE
	tristate "Freescale PPFE Driver"
	default m
	help
	  only compiled as module !
```
